# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group New Group
    ./: main.c xpt2046.c uart.c smg.c beep.c public.c wifi_control.c xpt2046.h wifi_control.h uart.h smg.h reg52.h public.h beep.h
